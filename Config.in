## Config.in
```kconfig
config BR2_PACKAGE_HELLOWORLD
    bool "helloworld"
    help
      Donne le trajet le plus court entre deux station de metro de Berlin
```
